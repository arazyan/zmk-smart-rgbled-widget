## dts/bindings/behaviors/k04,led-layer-color.yaml
```yaml
description: Drive the status LED color state (persistent / blink / toggle)

compatible: "k04,led-layer-color"

include: two_param.yaml
```
